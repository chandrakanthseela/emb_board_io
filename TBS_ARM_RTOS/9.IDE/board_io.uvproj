# Keil uVision project board_io.uvproj, settings and files
target Board_IO_MON_CON (ARM-ADS)
  device: LPC11C14/301 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: board_io +hex
  c flags: Optim=1
  c include: ..\1.APP\INC;..\2.OS\GENERIC\INC;..\2.OS\PORT\INC;..\3.ECU\INC;..\4.MCAL\INC
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group APP
    ../1.APP/: app_main.c app_tasks.c task_def.c
  group OS_PORT
    ../2.OS/PORT/: FreeRTOSCommonHooks.c heap_4.c port_m0.c
  group OS_GEN
    ../2.OS/GENERIC/: croutine.c list.c queue.c tasks.c timers.c
  group MCAL
    ../4.MCAL/: adc.c clocks.c ct32b0.c ct32b1.c eint.c gpio.c i2c.c iocon.c ssp0.c startup_LPC11xx.s system_LPC11xx.c uart.c
  group ECU
    ../3.ECU/: analog.c com.c dio.c pwm.c lm75.c
